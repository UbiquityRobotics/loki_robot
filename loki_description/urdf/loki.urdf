Commit message: fix urdf mesh refrences

File: loki_description/urdf/loki.urdf (robot description, URDF)
Before this commit: robot loki, 18 links, 17 joints
Links:
- link base_link: geometry 
- link sonar_0: geometry visual mesh filename=package://loki_description/meshes/HCSR04.stl
